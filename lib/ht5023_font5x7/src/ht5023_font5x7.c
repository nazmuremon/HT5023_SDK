// ht5023_font5x7.c — compact 5x7 bitmap font helpers
#include "ht5023_font5x7.h"

// 5x7 glyph columns, LSB = top row.
#define GLYPH(a,b,c,d,e) {a,b,c,d,e}

static const uint8_t g_space[5] = GLYPH(0x00,0x00,0x00,0x00,0x00);
static const uint8_t g_qmark[5] = GLYPH(0x02,0x01,0x51,0x09,0x06);
static const uint8_t g_excl[5]  = GLYPH(0x00,0x00,0x5F,0x00,0x00);
static const uint8_t g_dot[5]   = GLYPH(0x00,0x60,0x60,0x00,0x00);
static const uint8_t g_comma[5] = GLYPH(0x00,0x80,0x60,0x00,0x00);
static const uint8_t g_colon[5] = GLYPH(0x00,0x36,0x36,0x00,0x00);
static const uint8_t g_semic[5] = GLYPH(0x00,0x56,0x36,0x00,0x00);
static const uint8_t g_dash[5]  = GLYPH(0x08,0x08,0x08,0x08,0x08);
static const uint8_t g_plus[5]  = GLYPH(0x08,0x08,0x3E,0x08,0x08);
static const uint8_t g_slash[5] = GLYPH(0x20,0x10,0x08,0x04,0x02);
static const uint8_t g_bslash[5]= GLYPH(0x02,0x04,0x08,0x10,0x20);
static const uint8_t g_lpar[5]  = GLYPH(0x00,0x1C,0x22,0x41,0x00);
static const uint8_t g_rpar[5]  = GLYPH(0x00,0x41,0x22,0x1C,0x00);
static const uint8_t g_lbrk[5]  = GLYPH(0x00,0x7F,0x41,0x41,0x00);
static const uint8_t g_rbrk[5]  = GLYPH(0x00,0x41,0x41,0x7F,0x00);
static const uint8_t g_eq[5]    = GLYPH(0x14,0x14,0x14,0x14,0x14);
static const uint8_t g_lt[5]    = GLYPH(0x08,0x14,0x22,0x41,0x00);
static const uint8_t g_gt[5]    = GLYPH(0x00,0x41,0x22,0x14,0x08);
static const uint8_t g_uscore[5]= GLYPH(0x40,0x40,0x40,0x40,0x40);
static const uint8_t g_quote[5] = GLYPH(0x00,0x07,0x00,0x07,0x00);
static const uint8_t g_dquote[5]= GLYPH(0x07,0x00,0x07,0x00,0x00);
static const uint8_t g_star[5]  = GLYPH(0x14,0x08,0x3E,0x08,0x14);

static const uint8_t g_digits[10][5] = {
  GLYPH(0x3E,0x51,0x49,0x45,0x3E), // 0
  GLYPH(0x00,0x42,0x7F,0x40,0x00), // 1
  GLYPH(0x42,0x61,0x51,0x49,0x46), // 2
  GLYPH(0x21,0x41,0x45,0x4B,0x31), // 3
  GLYPH(0x18,0x14,0x12,0x7F,0x10), // 4
  GLYPH(0x27,0x45,0x45,0x45,0x39), // 5
  GLYPH(0x3C,0x4A,0x49,0x49,0x30), // 6
  GLYPH(0x01,0x71,0x09,0x05,0x03), // 7
  GLYPH(0x36,0x49,0x49,0x49,0x36), // 8
  GLYPH(0x06,0x49,0x49,0x29,0x1E), // 9
};

static const uint8_t g_upper[26][5] = {
  GLYPH(0x7E,0x11,0x11,0x11,0x7E), // A
  GLYPH(0x7F,0x49,0x49,0x49,0x36), // B
  GLYPH(0x3E,0x41,0x41,0x41,0x22), // C
  GLYPH(0x7F,0x41,0x41,0x22,0x1C), // D
  GLYPH(0x7F,0x49,0x49,0x49,0x41), // E
  GLYPH(0x7F,0x09,0x09,0x09,0x01), // F
  GLYPH(0x3E,0x41,0x49,0x49,0x7A), // G
  GLYPH(0x7F,0x08,0x08,0x08,0x7F), // H
  GLYPH(0x00,0x41,0x7F,0x41,0x00), // I
  GLYPH(0x20,0x40,0x41,0x3F,0x01), // J
  GLYPH(0x7F,0x08,0x14,0x22,0x41), // K
  GLYPH(0x7F,0x40,0x40,0x40,0x40), // L
  GLYPH(0x7F,0x02,0x0C,0x02,0x7F), // M
  GLYPH(0x7F,0x04,0x08,0x10,0x7F), // N
  GLYPH(0x3E,0x41,0x41,0x41,0x3E), // O
  GLYPH(0x7F,0x09,0x09,0x09,0x06), // P
  GLYPH(0x3E,0x41,0x51,0x21,0x5E), // Q
  GLYPH(0x7F,0x09,0x19,0x29,0x46), // R
  GLYPH(0x46,0x49,0x49,0x49,0x31), // S
  GLYPH(0x01,0x01,0x7F,0x01,0x01), // T
  GLYPH(0x3F,0x40,0x40,0x40,0x3F), // U
  GLYPH(0x1F,0x20,0x40,0x20,0x1F), // V
  GLYPH(0x3F,0x40,0x38,0x40,0x3F), // W
  GLYPH(0x63,0x14,0x08,0x14,0x63), // X
  GLYPH(0x07,0x08,0x70,0x08,0x07), // Y
  GLYPH(0x61,0x51,0x49,0x45,0x43), // Z
};

static char fold_case(char c) {
  if (c >= 'a' && c <= 'z') return (char)(c - ('a' - 'A'));
  return c;
}

bool ht5023_font5x7_is_supported(char c) {
  c = fold_case(c);
  if (c == ' ') return true;
  if (c >= '0' && c <= '9') return true;
  if (c >= 'A' && c <= 'Z') return true;
  switch (c) {
    case '!': case '.': case ',': case ':': case ';': case '-': case '+':
    case '/': case '\\': case '(': case ')': case '[': case ']': case '=':
    case '<': case '>': case '_': case '\'': case '"': case '*': case '?':
      return true;
    default:
      return false;
  }
}

const uint8_t* ht5023_font5x7_glyph(char c) {
  c = fold_case(c);
  if (c == ' ') return g_space;
  if (c >= '0' && c <= '9') return g_digits[(unsigned)(c - '0')];
  if (c >= 'A' && c <= 'Z') return g_upper[(unsigned)(c - 'A')];

  switch (c) {
    case '!': return g_excl;
    case '.': return g_dot;
    case ',': return g_comma;
    case ':': return g_colon;
    case ';': return g_semic;
    case '-': return g_dash;
    case '+': return g_plus;
    case '/': return g_slash;
    case '\\': return g_bslash;
    case '(': return g_lpar;
    case ')': return g_rpar;
    case '[': return g_lbrk;
    case ']': return g_rbrk;
    case '=': return g_eq;
    case '<': return g_lt;
    case '>': return g_gt;
    case '_': return g_uscore;
    case '\'': return g_quote;
    case '"': return g_dquote;
    case '*': return g_star;
    default: return g_qmark;
  }
}

